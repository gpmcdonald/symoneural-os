SUMMARY = "SyMoNeuRaL XFCE Desktop Image"
LICENSE = "MIT"
inherit core-image
IMAGE_FEATURES += "x11-base x11-sddm"
IMAGE_INSTALL += "packagegroup-core-x11-utils"
