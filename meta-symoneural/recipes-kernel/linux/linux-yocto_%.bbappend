# Add kernel config fragments here
FILESEXTRAPATHS:prepend := "${THISDIR}/linux-yocto:"
