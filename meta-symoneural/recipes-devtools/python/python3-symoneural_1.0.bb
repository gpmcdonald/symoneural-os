SUMMARY = "Custom Python helper for SyMoNeuRaL"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"
# Placeholder for your NHL stats or AI scripts
